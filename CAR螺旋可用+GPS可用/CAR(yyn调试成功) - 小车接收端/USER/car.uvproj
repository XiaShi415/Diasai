# Keil uVision project car.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: car +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c car_communcation.c car_drive.c car_hcsr04.c car_speed.c car_system.c delay.c time.c vlc.c GPS.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_dma.c
